# Keil uVision project 流水呼吸灯.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 流水呼吸灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: removeunused
  group Source Group 1
    ./: STARTUP.A51 main.c
