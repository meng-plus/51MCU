# Keil uVision project 多机通信.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 多机通信 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c Uart3_STC8G.c Uart1.c TM4_STC8.c MultiSystem_UART.c Afx.h SelSignal.c ModBusSlave.c
